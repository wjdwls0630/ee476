* Harness to generate realistic inputs to DUT
.global vdd! vss!

* Give it a name that won't conflict with students' subcircuits
* INVERTER_D1_ASDF.ckt generated by alu/cad.py
.inc "INVERTER_D1_ASDF.ckt"

.subckt TEST_BUFFER vi vo
xi0 vi vo_bar INVERTER_D1_ASDF
xi1 vo_bar vo INVERTER_D1_ASDF
.ends TEST_BUFFER

.PARAM OUTPUT_LOAD = 40f

* ======================
* INPUT BUFFERS
* ======================
xbuf0  in_op0<0>   op0<0>  TEST_BUFFER
xbuf1  in_op0<1>   op0<1>  TEST_BUFFER
xbuf2  in_op0<2>   op0<2>  TEST_BUFFER
xbuf3  in_op0<3>   op0<3>  TEST_BUFFER
xbuf4  in_op0<4>   op0<4>  TEST_BUFFER
xbuf5  in_op0<5>   op0<5>  TEST_BUFFER
xbuf6  in_op0<6>   op0<6>  TEST_BUFFER
xbuf7  in_op0<7>   op0<7>  TEST_BUFFER
xbuf8  in_op0<8>   op0<8>  TEST_BUFFER
xbuf9  in_op0<9>   op0<9>  TEST_BUFFER
xbuf10 in_op0<10>  op0<10> TEST_BUFFER
xbuf11 in_op0<11>  op0<11> TEST_BUFFER
xbuf12 in_op0<12>  op0<12> TEST_BUFFER
xbuf13 in_op0<13>  op0<13> TEST_BUFFER
xbuf14 in_op0<14>  op0<14> TEST_BUFFER
xbuf15 in_op0<15>  op0<15> TEST_BUFFER

xbuf00  in_op1<0>   op1<0>  TEST_BUFFER
xbuf01  in_op1<1>   op1<1>  TEST_BUFFER
xbuf02  in_op1<2>   op1<2>  TEST_BUFFER
xbuf03  in_op1<3>   op1<3>  TEST_BUFFER
xbuf04  in_op1<4>   op1<4>  TEST_BUFFER
xbuf05  in_op1<5>   op1<5>  TEST_BUFFER
xbuf06  in_op1<6>   op1<6>  TEST_BUFFER
xbuf07  in_op1<7>   op1<7>  TEST_BUFFER
xbuf08  in_op1<8>   op1<8>  TEST_BUFFER
xbuf09  in_op1<9>   op1<9>  TEST_BUFFER
xbuf010 in_op1<10>  op1<10> TEST_BUFFER
xbuf011 in_op1<11>  op1<11> TEST_BUFFER
xbuf012 in_op1<12>  op1<12> TEST_BUFFER
xbuf013 in_op1<13>  op1<13> TEST_BUFFER
xbuf014 in_op1<14>  op1<14> TEST_BUFFER
xbuf015 in_op1<15>  op1<15> TEST_BUFFER

xbuf20 in_ctrl<2> ctrl<2> TEST_BUFFER
xbuf21 in_ctrl<1> ctrl<1> TEST_BUFFER
xbuf22 in_ctrl<0> ctrl<0> TEST_BUFFER

* ======================
* LOADING
* ======================
c0   alu_out<15> 0 OUTPUT_LOAD
c1   alu_out<14> 0 OUTPUT_LOAD
c2   alu_out<13> 0 OUTPUT_LOAD
c3   alu_out<12> 0 OUTPUT_LOAD
c4   alu_out<11> 0 OUTPUT_LOAD
c5   alu_out<10> 0 OUTPUT_LOAD
c6   alu_out<9>  0 OUTPUT_LOAD
c7   alu_out<8>  0 OUTPUT_LOAD
c8   alu_out<7>  0 OUTPUT_LOAD
c9   alu_out<6>  0 OUTPUT_LOAD
c10  alu_out<5>  0 OUTPUT_LOAD
c11  alu_out<4>  0 OUTPUT_LOAD
c12  alu_out<3>  0 OUTPUT_LOAD
c13  alu_out<2>  0 OUTPUT_LOAD
c14  alu_out<1>  0 OUTPUT_LOAD
c15  alu_out<0>  0 OUTPUT_LOAD

c16  c_flag  0 OUTPUT_LOAD
c17  n_flag  0 OUTPUT_LOAD
c18  v_flag  0 OUTPUT_LOAD

.INC ALU.ckt
