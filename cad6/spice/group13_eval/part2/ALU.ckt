* Circuit auto-generated by grader
.global vdd! vss!
.INC "ALU.pex.netlist"
* Instantiate the post-layout circuit
xdut  OP1<15> V_FLAG C_FLAG N_FLAG VSS! VDD! CTRL<2> CTRL<0> CTRL<1>  OP0<0> OP1<0> ALU_OUT<0> OP0<1> OP1<1> ALU_OUT<1> OP0<2> OP1<2> ALU_OUT<2>  OP0<3> OP1<3> ALU_OUT<3> OP0<4> OP1<4> ALU_OUT<4> OP0<5> OP1<5> ALU_OUT<5>  OP0<6> OP1<6> ALU_OUT<6> OP0<7> OP1<7> ALU_OUT<7> OP0<8> OP1<8> ALU_OUT<8>  OP0<9> OP1<9> ALU_OUT<9> OP0<10> OP1<10> ALU_OUT<10> OP0<11> OP1<11>  ALU_OUT<11> OP0<12> OP1<12> ALU_OUT<12> OP0<13> OP1<13> ALU_OUT<13> OP0<14>  OP1<14> ALU_OUT<14> OP0<15> ALU_OUT<15> ALU
